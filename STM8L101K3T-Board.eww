<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FWLib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\STM8L101K3T-Board.ewp</path>
  </project>
  <batchBuild/>
</workspace>


