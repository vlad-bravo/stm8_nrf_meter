# IAR project STM8L101K3T-Board.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCDiagSuppress: Pe111,Pe167,Pe188,Pe549,Pa089
  ICCSTM8.CCIncludePath2: inc; Libraries\STM8L10x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: STM8L101K3T-Board.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: functions.c main.c nrf.c stm8l10x_it.c
    Debug/Exe/: FWLib.a
